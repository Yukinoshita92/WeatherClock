# Keil uVision project WeatherClock_FreeRTOS_HAL.uvprojx, settings and files
target WeatherClock_FreeRTOS_HAL (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: WeatherClock_FreeRTOS_HAL +hex
  AfterMake: C:\Keil_v5\ARM\ARM_Compiler_5.06u7\bin\fromelf --bin -o "$L@L.bin" #L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../App;../App/font;../App/image;../App/page;../int_driver;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8009000 size 0x77000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group App/font
    ../App/font/: font.h font12_sbold.c font16_sbold.c font20_sbold.c font24_bold.c font24_sbold.c font32_sbold.c font50_sbold .c font60_extra .c font76_bold .c
  group App/image
    ../App/image/: icon_5g.c icon_charge.c icon_crowd.c icon_crowdwind.c icon_moon.c icon_na.c icon_rain.c icon_reloading.c icon_sumcrowdwind.c icon_sun.c icon_sunrain.c icon_sunset.c icon_sunwind.c icon_temperature.c icon_thunder.c icon_wifi2.c icon_yin.c icon_yuki.c image.c image.h image_error.c image_main.c image1.c wifi_image.c
  group App/page
    ../App/page/: error.c main_page.c page.h welcome.c wifi_connect.c
  group int_driver
    ../int_driver/: aht20.c aht20.h tim_delay.c tim_delay.h esp_at.c esp_at.h st7789.c st7789.h crc32.c crc32.h magic_header.c magic_header.h esp_at_ota.c esp_at_ota.h Int_W25Q64.c Int_W25Q64.h ota_flag.c ota_flag.h Int_AT24C02.c Int_AT24C02.h eeprom_flag_header.h ota_version.c ota_version.h byteorder.h esp_at_mqtt.c esp_at_mqtt.h onenet_mqtt.c onenet_mqtt.h
  group App
    ../App/: app.c app.h app_head.h board.c UI.c UI.h wifi.c workqueue.c workqueue.h ota.c ota.h log.c log.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
